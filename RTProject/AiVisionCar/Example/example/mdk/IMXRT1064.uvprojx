# Keil uVision project IMXRT1064.uvprojx, settings and files
target flexspi_nor_release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.10.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: IMXRT1064.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1064DVL6A, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186,6329,1
  c include: ..\..\..\CMSIS\Include;..\..\..\Device;..\..\..\Device\board;..\..\..\Device\drivers\LQRT1064;..\..\..\Device\drivers\MIMXRT1064;..\..\..\Device\startup\arm;..\..\..\Device\utilities;..\..\..\Device\xip;..\..\..\Device\drivers\MIMXRT1064\camera;..\..\..\Device\fatfs\fatfs\source\fsl_sd_disk;..\..\..\Device\fatfs\fatfs\source;..\..\..\Device\fatfs\sdmmc\inc;..\..\example;..\sd;..\..\..\Device\drivers\LQRT1064\test
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\Device\startup\arm\MIMXRT1064_flexspi_nor.scf
  link misc: --remove 
--keep=*(.boot_hdr.ivt) 
--keep=*(.boot_hdr.boot_data) 
--keep=*(.boot_hdr.conf) 
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group source
    ../: main.c irq.c include.h include_all.h
    ../sd/: ffconf.h
  group board
    ../../../Device/board/: board.c clock_config.c pin_mux.c
  group lq
    ../../../Device/drivers/LQRT1064/: ANO_DT.c ICM20602_SOFTSPI.c LQ_12864SPI.c LQ_9AX.c LQ_ADC.c LQ_CSI.c LQ_Camera.c LQ_DMA.c LQ_Encoder.c LQ_FlexCamera.c LQ_FlexioMT9V034.c LQ_FLASH.c LQ_FlexCAN.c LQ_GPT.c LQ_GPIO.c LQ_IIC.c LQ_ICM20602.c LQ_KEY.c LQ_LED.c LQ_MT9V034M.c LQ_MPU6050.c LQ_OV7725M.c LQ_PIT.c LQ_PWM.c LQ_QTMR.c LQ_SOFTIIC.c LQ_SGP18T.c LQ_SPI.c LQ_SDCard.c LQ_SYSTICK.c LQ_SCCB.c LQ_UART.c LQ_UART_DMA.c LQ_W25Q128.c
  group test
    ../../../Device/drivers/LQRT1064/test/: TEST_9AX.c TEST_ADC.c TEST_Camera.c TEST_DMA.c TEST_Encoder.c TEST_FLASH.c TEST_FlexCamera.c TEST_FlexCAN.c TEST_GPT.c TEST_ICM20602.c TEST_MPU6050.c TEST_PIT.c TEST_PWM.c TEST_QTMR.c TEST_SYSTICK.c TEST_Rtwdog.c TEST_Tempmon.c TEST_TRNG.c TEST_UART.c TEST_WDog.c TEST_Ultrasonic.c TEST_VL53.c
  group drivers
    ../../../Device/drivers/MIMXRT1064/: fsl_clock.c fsl_common.c fsl_lpuart.c fsl_gpio.c fsl_csi.c fsl_lpi2c.c fsl_adc.c fsl_cache.c fsl_dmamux.c fsl_edma.c fsl_enc.c fsl_flexspi.c fsl_gpt.c fsl_lpspi.c fsl_lpuart_edma.c fsl_pit.c fsl_pwm.c fsl_qtmr.c fsl_rtwdog.c fsl_tempmon.c fsl_trng.c fsl_usdhc.c fsl_wdog.c fsl_xbara.c fsl_xbarb.c fsl_flexio.c fsl_flexio_camera.c fsl_flexio_camera_edma.c fsl_flexcan.c
    ../../../Device/drivers/MIMXRT1064/camera/: fsl_csi_camera_adapter.c fsl_sccb.c
  group startup
    ../../../Device/: system_MIMXRT1064.c
    ../../../Device/startup/arm/: startup_MIMXRT1064_ram.s
  group utilities
    ../../../Device/utilities/: fsl_assert.c fsl_debug_console.c fsl_io.c fsl_log.c fsl_str.c
  group xip
    ../../../Device/xip/: evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_sdram_ini_dcd.c fsl_flexspi_nor_boot.c
  group fatfs
    ../../../Device/fatfs/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c
    ../../../Device/fatfs/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c
  group sdmmc
    ../sd/: fsl_sdmmc_event.c fsl_sdmmc_host.c
    ../../../Device/fatfs/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group doc
    ../: readme.txt
target flexspi_nor_sdram_release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.10.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SKIP_SYSCLK_INIT, XIP_EXTERNAL_FLASH=1, DEBUG, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, CPU_MIMXRT1064DVL6A, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..\..\..\Device;..\..\..\Device\board;..\..\..\Device\drivers\LQRT1064;..\..\..\Device\drivers\MIMXRT1064;..\..\..\Device\startup\arm;..\..\..\Device\utilities;..\..\..\Device\xip;..\..\..\CMSIS\Include;..\..\..\Device\fatfs\fatfs\source;..\..\..\Device\fatfs\fatfs\source\fsl_sd_disk;..\..\..\Device\fatfs\sdmmc\inc;..\..\..\Device\drivers\MIMXRT1064\camera;..\..\example;..\sd;..\..\..\Device\drivers\LQRT1064\test
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\Device\startup\arm\MIMXRT1064_flexspi_nor_sdram.scf
  link misc: as above

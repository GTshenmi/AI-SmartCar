# IAR project Backup of IMXRT1064.ewp, settings and files
configuration flexspi_nor_release (ARM)
  General.OGChipSelectEditMenu: MIMXRT1064xxx6A NXP MIMXRT1064xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; DEBUG; CPU_MIMXRT1064DVL6A; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..; ..\..\..\CMSIS\Include; ..\..\..\Device\board; ..\..\..\Device; ..\..\..\Device\drivers\LQRT1064; ..\..\..\Device\drivers\MIMXRT1064\camera; ..\..\..\Device\drivers\MIMXRT1064; ..\..\..\Device\startup\iar; ..\..\..\Device\utilities; ..\..\..\Device\xip; ..\..\..\Device\fatfs\fatfs\source; ..\..\..\Device\fatfs\fatfs\source\fsl_sd_disk; ..\..\..\Device\fatfs\sdmmc\inc; ..\sd; ..\..\..\Device\drivers\LQRT1064\test
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..\..\..\Device\startup\iar
  OBJCOPY.OOCOutputFile: IMXRT.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\Device\startup\iar\LQ_RT1064_QSPI_NOSDRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; DEBUG; CPU_MIMXRT1064DVL6A; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1
  ICCARM.CCIncludePath2: ..; ..\..\..\CMSIS\Include; ..\..\..\Device\board; ..\..\..\Device; ..\..\..\Device\drivers\LQRT1064; ..\..\..\Device\drivers\MIMXRT1064\camera; ..\..\..\Device\drivers\MIMXRT1064; ..\..\..\Device\startup\iar; ..\..\..\Device\utilities; ..\..\..\Device\xip; ..\..\..\Device\fatfs\fatfs\source; ..\..\..\Device\fatfs\fatfs\source\fsl_sd_disk; ..\..\..\Device\fatfs\sdmmc\inc; ..\sd
  ILINK.IlinkIcfFile: ..\..\..\Device\startup\iar\LQ_RT1064_QSPI_SDRAM.icf
  group board
    ../../../Device/board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../../../Device/drivers/MIMXRT1064/: fsl_adc.c fsl_adc.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_csi.c fsl_csi.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_enc.c fsl_enc.h fsl_flexcan.c fsl_flexcan.h fsl_flexio.c fsl_flexio.h fsl_flexio_camera.c fsl_flexio_camera.h fsl_flexio_camera_edma.c fsl_flexio_camera_edma.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpspi.c fsl_lpspi.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_pit.c fsl_pit.h fsl_pwm.c fsl_pwm.h fsl_qtmr.c fsl_qtmr.h fsl_rtwdog.c fsl_rtwdog.h fsl_tempmon.c fsl_tempmon.h fsl_trng.c fsl_trng.h fsl_usdhc.c fsl_usdhc.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h
    ../../../Device/drivers/MIMXRT1064/camera/: fsl_camera.h fsl_camera_device.h fsl_camera_receiver.h fsl_csi_camera_adapter.c fsl_csi_camera_adapter.h fsl_sccb.c fsl_sccb.h fsl_video_common.h
  group fatfs
    ../../../Device/fatfs/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c integer.h
    ../../../Device/fatfs/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group lq
    ../../../Device/drivers/LQRT1064/: ANO_DT.c ANO_DT.h LQ_12864.h LQ_12864SPI.c LQ_9AX.c LQ_9AX.h LQ_ADC.c LQ_ADC.h LQ_Camera.c LQ_Camera.h LQ_CSI.c LQ_CSI.h LQ_DMA.c LQ_DMA.h LQ_Encoder.c LQ_Encoder.h LQ_FLASH.c LQ_FLASH.h LQ_FlexCamera.c LQ_FlexCamera.h LQ_FlexCAN.c LQ_FlexCAN.h LQ_FlexioMT9V034.c LQ_FlexioMT9V034.h LQ_GPIO.c LQ_GPIO.h LQ_GPIO_Cfg.h LQ_GPT.c LQ_GPT.h LQ_ICM20602.c LQ_ICM20602.h LQ_IIC.c LQ_IIC.h LQ_KEY.c LQ_KEY.h LQ_LED.c LQ_LED.h LQ_MPU6050.c LQ_MPU6050.h LQ_MT9V034M.c LQ_MT9V034M.h LQ_OV7725M.c LQ_OV7725M.h LQ_PIT.c LQ_PIT.h LQ_PWM.c LQ_PWM.h LQ_QTMR.c LQ_QTMR.h LQ_SCCB.c LQ_SCCB.h LQ_SDCard.c LQ_SDCard.h LQ_SGP18T.c LQ_SGP18T.h LQ_SOFTIIC.c LQ_SOFTIIC.h LQ_SPI.c LQ_SPI.h LQ_SYSTICK.c LQ_SYSTICK.h LQ_UART.c LQ_UART.h LQ_UART_DMA.c LQ_UART_DMA.h LQ_W25Q128.c LQ_W25Q128.h
  group sdmmc
    ../../../Device/fatfs/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
    ../../../Device/fatfs/sdmmc/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
    ../sd/: fsl_sdmmc_event.c fsl_sdmmc_event.h fsl_sdmmc_host.c
  group source
    ../sd/: ffconf.h
    ../: include.h include_all.h irq.c main.c
  group startup
    ../../../Device/startup/iar/: startup_MIMXRT1064.s
    ../../../Device/: system_MIMXRT1064.c
  group test
    ../../../Device/drivers/LQRT1064/test/: TEST_9AX.c TEST_9AX.h TEST_ADC.c TEST_ADC.h TEST_Camera.c TEST_Camera.h TEST_DMA.c TEST_DMA.h TEST_Encoder.c TEST_Encoder.h TEST_FLASH.c TEST_FLASH.h TEST_FlexCamera.c TEST_FlexCamera.h TEST_FlexCAN.c TEST_FlexCAN.h TEST_GPT.c TEST_GPT.h TEST_ICM20602.c TEST_ICM20602.h TEST_MPU6050.c TEST_MPU6050.h TEST_PIT.c TEST_PIT.h TEST_PWM.c TEST_PWM.h TEST_QTMR.c TEST_QTMR.h TEST_Rtwdog.c TEST_Rtwdog.h TEST_SYSTICK.c TEST_SYSTICK.h TEST_Tempmon.c TEST_Tempmon.h TEST_TRNG.c TEST_TRNG.h TEST_UART.c TEST_UART.h TEST_Ultrasonic.c TEST_Ultrasonic.h TEST_VL53.c TEST_VL53.h TEST_WDog.c TEST_WDog.h
  group utilities
    ../../../Device/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_io.c fsl_io.h fsl_log.c fsl_log.h fsl_str.c fsl_str.h
  group xip
    ../../../Device/xip/: evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_flexspi_nor_config.h evkmimxrt1064_sdram_ini_dcd.c evkmimxrt1064_sdram_ini_dcd.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h

# IAR project IMXRT1064.ewp, settings and files
configuration flexspi_nor_release (ARM)
  General.OGChipSelectEditMenu: MIMXRT1064xxx6A NXP MIMXRT1064xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; DEBUG; CPU_MIMXRT1064DVL6A; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..; ..\..\..\CMSIS\Include; ..\..\..\Device\board; ..\..\..\Device; ..\..\..\Device\drivers\MIMXRT1064\camera; ..\..\..\Device\drivers\MIMXRT1064; ..\..\..\Device\startup\iar; ..\..\..\Device\utilities; ..\..\..\Device\xip; ..\..\..\Device\fatfs\fatfs\source; ..\..\..\Device\fatfs\fatfs\source\fsl_sd_disk; ..\..\..\Device\fatfs\sdmmc\inc; ..\sd; ..\..\..\Driver; ..\..\..\Driver\SysDriver; ..\..\..\Driver\SysDriverLQ; ..\..\..\Driver\UsrDriver; ..\..\..\Driver\UsrDriver\LCD; ..\..\..\Driver\UsrDriver\SD; ..\..\..\Driver\UsrDriver\Camera; ..\..\..\OS; ..\..\..\OS\Debug; ..\..\..\OS\Device; ..\..\..\OS\Device\BEEP; ..\..\..\OS\Device\BLE; ..\..\..\OS\Device\Capture; ..\..\..\OS\Device\Communicate; ..\..\..\OS\Device\Demo; ..\..\..\OS\Device\ESensor; ..\..\..\OS\Device\KEY; ..\..\..\OS\Device\LED; ..\..\..\OS\Device\Motor; ..\..\..\OS\Device\Screen; ..\..\..\OS\Device\SDCard; ..\..\..\OS\Device\Servo; ..\..\..\OS\Device\Switch; ..\..\..\OS\Device\WirelessSerial; ..\..\..\OS\Fatfs; ..\..\..\OS\Malloc; ..\..\..\OS\Task; ..\..\..\OS\Time; ..\..\..\OS\UI; ..\..\..\App; ..\..\..\App\Sys; ..\..\..\App\Usr; ..\..\..\App\Usr\NeuralNetwork
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..\..\..\Device\startup\iar
  OBJCOPY.OOCOutputFile: IMXRT.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\Device\startup\iar\LQ_RT1064_QSPI_NOSDRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; DEBUG; CPU_MIMXRT1064DVL6A; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1
  ICCARM.CCIncludePath2: ..; ..\..\..\CMSIS\Include; ..\..\..\Device\board; ..\..\..\Device; ..\..\..\Device\drivers\LQRT1064; ..\..\..\Device\drivers\MIMXRT1064\camera; ..\..\..\Device\drivers\MIMXRT1064; ..\..\..\Device\startup\iar; ..\..\..\Device\utilities; ..\..\..\Device\xip; ..\..\..\Device\fatfs\fatfs\source; ..\..\..\Device\fatfs\fatfs\source\fsl_sd_disk; ..\..\..\Device\fatfs\sdmmc\inc; ..\sd
  ILINK.IlinkIcfFile: ..\..\..\Device\startup\iar\LQ_RT1064_QSPI_SDRAM.icf
  group App
    ../../../App/: app.c app.h foo.c foo.h include.h init.c init.h
  group App/Sys
    ../../../App/Sys/: ctrlsys.c ctrlsys.h filter.c filter.h kalman_filter.c kalman_filter.h matrix.c matrix.h pid_ctrl.c pid_ctrl.h sort.c sort.h sys.h sysmath.c sysmath.h
  group App/Usr
    ../../../App/Usr/: camera_algorithm.c camera_algorithm.h control.c control.h dataprocess.c dataprocess.h element.c element.h parameter.c parameter.h usr.h
  group App/Usr/NeuralNetwork
    ../../../App/Usr/NeuralNetwork/: element.nncu.c model.nncu.h neuralnetwork.c neuralnetwork.h NNLayer.c NNLayer.h tracking.nncu.c
  group Doc
    ../: readme.txt
  group Driver
    ../../../Driver/: driver.h
  group Driver/SysDriver
    ../../../Driver/SysDriver/: adc.c adc.h dma.c dma.h enc.c enc.h gpio.c gpio.h henv.c henv.h iic.c iic.h platform.h pwm.c pwm.h spi.c spi.h sys_driver.h systime.c systime.h tim.c tim.h uart.c uart.h
  group Driver/SysDriverLQ
    ../../../Driver/SysDriverLQ/: LQ_ADC.c LQ_ADC.h LQ_DMA.c LQ_DMA.h LQ_Encoder.c LQ_Encoder.h LQ_GPIO.c LQ_GPIO.h LQ_GPIO_Cfg.h LQ_GPT.c LQ_GPT.h LQ_IIC.c LQ_IIC.h LQ_PIT.c LQ_PIT.h LQ_PWM.c LQ_PWM.h LQ_QTMR.c LQ_QTMR.h LQ_SOFTIIC.c LQ_SOFTIIC.h LQ_SPI.c LQ_SPI.h LQ_SYSTICK.c LQ_SYSTICK.h LQ_UART.c LQ_UART.h LQ_UART_DMA.c LQ_UART_DMA.h picture.h sys_driverlq.h
  group Driver/UsrDriver
    ../../../Driver/UsrDriver/: usr_driver.h
  group Driver/UsrDriver/Camera
    ../../../Driver/UsrDriver/Camera/: camera.c camera.h LQ_Camera.c LQ_Camera.h LQ_CSI.c LQ_CSI.h LQ_MT9V034M.c LQ_MT9V034M.h
  group Driver/UsrDriver/LCD
    ../../../Driver/UsrDriver/LCD/: lcd_driver.c lcd_driver.h
  group Driver/UsrDriver/SD
    ../../../Driver/UsrDriver/SD/: sd.c sd.h
  group Hal/board
    ../../../Device/board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group Hal/fsl
    ../../../Device/drivers/MIMXRT1064/: fsl_adc.c fsl_adc.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_csi.c fsl_csi.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_enc.c fsl_enc.h fsl_flexcan.c fsl_flexcan.h fsl_flexio.c fsl_flexio.h fsl_flexio_camera.c fsl_flexio_camera.h fsl_flexio_camera_edma.c fsl_flexio_camera_edma.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpspi.c fsl_lpspi.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_pit.c fsl_pit.h fsl_pwm.c fsl_pwm.h fsl_qtmr.c fsl_qtmr.h fsl_rtwdog.c fsl_rtwdog.h fsl_tempmon.c fsl_tempmon.h fsl_trng.c fsl_trng.h fsl_usdhc.c fsl_usdhc.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h
    ../../../Device/drivers/MIMXRT1064/camera/: fsl_camera.h fsl_camera_device.h fsl_camera_receiver.h fsl_csi_camera_adapter.c fsl_csi_camera_adapter.h fsl_sccb.c fsl_sccb.h fsl_video_common.h
  group Hal/sdmmc
    ../../../Device/fatfs/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
    ../../../Device/fatfs/sdmmc/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
    ../sd/: fsl_sdmmc_event.c fsl_sdmmc_event.h fsl_sdmmc_host.c
  group Hal/startup
    ../../../Device/startup/iar/: startup_MIMXRT1064.s
    ../../../Device/: system_MIMXRT1064.c
  group Hal/utilities
    ../../../Device/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_io.c fsl_io.h fsl_log.c fsl_log.h fsl_str.c fsl_str.h
  group Hal/xip
    ../../../Device/xip/: evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_flexspi_nor_config.h evkmimxrt1064_sdram_ini_dcd.c evkmimxrt1064_sdram_ini_dcd.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group OS
    ../../../OS/: devices_config.c devices_config.h os.c os.h resource_config.c resource_config.h
  group OS/Debug
    ../../../OS/Debug/: ano_dt.c ano_dt.h console.c console.h debug.h print.c print.h
  group OS/Device
    ../../../OS/Device/: device.h
  group OS/Device/BEEP
    ../../../OS/Device/BEEP/: beep.c beep.h
  group OS/Device/BLE
    ../../../OS/Device/BLE/: bluetooth.c bluetooth.h
  group OS/Device/Capture
    ../../../OS/Device/Capture/: capture.c capture.h image.c image.h
  group OS/Device/Communicate
    ../../../OS/Device/Communicate/: communicate.c communicate.h
  group OS/Device/Demo
    ../../../OS/Device/Demo/: demo.c demo.h
  group OS/Device/ESensor
    ../../../OS/Device/ESensor/: esensor.c esensor.h
  group OS/Device/KEY
    ../../../OS/Device/KEY/: key.c key.h
  group OS/Device/LED
    ../../../OS/Device/LED/: led.c led.h
  group OS/Device/Motor
    ../../../OS/Device/Motor/: motor.c motor.h
  group OS/Device/Screen
    ../../../OS/Device/Screen/: screen.c screen.h
  group OS/Device/SDCard
    ../../../OS/Device/SDCard/: sdcard.c sdcard.h
  group OS/Device/Servo
    ../../../OS/Device/Servo/: servo.c servo.h
  group OS/Device/Switch
    ../../../OS/Device/Switch/: dipswitch.c dipswitch.h switch.c switch.h
  group OS/Device/WirelessSerial
    ../../../OS/Device/WirelessSerial/: wirelessserial.c wirelessserial.h
  group OS/Fatfs
    ../../../OS/FatFs/: file.c file.h
  group OS/Fatfs/fatfs
    ../../../Device/fatfs/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c integer.h
    ../sd/: ffconf.h
    ../../../Device/fatfs/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group OS/Malloc
    ../../../OS/Malloc/: malloc.c malloc.h
  group OS/Task
    ../../../OS/Task/: task.c task.h
  group OS/Time
    ../../../OS/Time/: ostime.c ostime.h softtimer.c softtimer.h
  group OS/UI
    ../../../OS/UI/: ui.c ui.h
  group User
    ../: irq.c main.c
